# Keil uVision project usb-can.uvprojx, settings and files
target Motor (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MDR1986BE92 Milandr
  pack: Keil.MDR1986BExx.1.5.3
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Hand +hex
  c flags: Optim=1 oTime=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: ARM_MATH_CM3
  c include: .\Source;.\Freemaster;.\RTE\Device\MDR1986BE92;.\MDR1986BExx\1.5\Libraries\MDR32F9Qx_StdPeriph_Driver\src;.\MDR1986BExx\1.5\Libraries\MDR32F9Qx_StdPeriph_Driver\inc;.\MDR1986BExx\1.5\Libraries\CMSIS\CM3\CoreSupport;.\MDR1986BExx\1.5\Libraries\CMSIS\CM3\DeviceSupport\MDR32F9Qx\inc;.\MDR1986BExx\1.5\Config;.\MDR1986BExx\1.5\Libraries;.\Definition;.\MDR1986BExx\1.5\Libraries\MDR32F9Qx_StdPeriph_Driver\inc\USB_Library;.\MDR1986BExx\1.5\Libraries\MDR32F9Qx_StdPeriph_Driver\src\USB_Library
  asm misc: --debug --dwarf2
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./Source/: timer_control.c can.c usb.c main.c
  group Drivers
    ./MDR1986BExx/1.5/Libraries/: arm_cortexM3l_math.lib
    ./MDR1986BExx/1.5/Libraries/MDR32F9Qx_StdPeriph_Driver/src/: MDR32F9Qx_adc.c MDR32F9Qx_comp.c MDR32F9Qx_dma.c MDR32F9Qx_dsp.c MDR32F9Qx_port.c MDR32F9Qx_power.c MDR32F9Qx_rst_clk.c MDR32F9Qx_ssp.c MDR32F9Qx_timer.c MDR32F9Qx_uart.c MDR32F9Qx_can.c MDR32F9Qx_usb.c
    ./MDR1986BExx/1.5/Libraries/MDR32F9Qx_StdPeriph_Driver/src/USB_Library/: MDR32F9Qx_usb_CDC.c MDR32F9Qx_usb_device.c
software components: Device:Startup 1.5
